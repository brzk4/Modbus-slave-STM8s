# IAR project EWSTM8_project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Libraries\STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: EWSTM8_project.srec
  ILINK.IlinkOutputFile: EWSTM8_project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: stm8s_conf.h stm8s_it.h
  group Source Files
    ../src/: main.c stm8s_it.c
